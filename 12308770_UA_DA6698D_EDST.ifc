Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-22T10:44:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 22 10:44:26 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\7b3ee4da-c21c-4361-b68a-f795bfa2d582\f8ad7b8f-00d0-46fe-a485-8a5a24da146c\ifc * Database version: 5507 * Database creation date: Wed Feb 22 10:44:25 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 22 10:44:25 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 22 10:44:25 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12308770_UA_DA6698D_EDST:28669855_UA_12308770_DA6698D_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 28669855_UA_12308770_DA6698D_EDST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28669855_UA_12308770_DA6698D_EDST
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_ExhaustAir, z_Miele_Design_Glass, Aluminum, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 898 mm; Depth: 598 mm

# IfcDistributionPort, Port_355746
Description: Flow; FlowDirection: SOURCEANDSINK
